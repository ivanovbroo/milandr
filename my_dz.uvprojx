# Keil uVision project my_dz.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_dz +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=2
  c include: .\Generic;.\Basic;.\Display;.\Headers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Basic
    ./Basic/: main.c led.c settingsports.c timer.c lcdtext.c
  group Headers
    ./Headers/: led.h settingsports.h timer.h lcdtext.h
  group Display
    ./Display/: Font_6x8.c font_defs.h lcd.c lcd.h systick.c systick.h text.c text.h types.h
software components: Device:Startup 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
